# Repository cherry-takuan/SST39SF010A-Writer

File README.md:

# SST39SF010A-Writer
SST39SF010A Reader/Writer

## KiCad design ROM_Writer.kicad_pcb

Parts:
C1, C3, C4, C5, C6, C7, C8: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: C_Polarized; CP_Radial_D5.0mm_P2.50mm
D1, D2: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: USB_B; USB_B_OST_USB-B1HSxx_Horizontal
J2: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J3: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Horizontal
R1, R2: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1: R_Network08; R_Array_SIP9
U1, U2, U3: 74LS373; DIP-20_W7.62mm
U4: CH340E; MSOP-10_3x3mm_P0.5mm
U5: SST39SF010A; DIP-32_W15.24mm
U6: CH32V003F4P6; SSOP-20_4.4x6.5mm_P0.65mm

Connections:
/Addr0: U2.2 (O0), U3.3 (D0), U5.12 (A0)
/Addr1: U2.5 (O1), U3.4 (D1), U5.11 (A1)
/Addr2: U2.6 (O2), U3.7 (D2), U5.10 (A2)
/Addr3: U2.9 (O3), U3.8 (D3), U5.9 (A3)
/Addr4: U2.12 (O4), U3.13 (D4), U5.8 (A4)
/Addr5: U2.15 (O5), U3.14 (D5), U5.7 (A5)
/Addr6: U2.16 (O6), U3.17 (D6), U5.6 (A6)
/Addr7: U2.19 (O7), U3.18 (D7), U5.5 (A7)
/Addr8: U1.2 (O0), U2.3 (D0), U5.27 (A8)
/Addr9: U1.5 (O1), U2.4 (D1), U5.26 (A9)
/Addr10: U1.6 (O2), U2.7 (D2), U5.23 (A10)
/Addr11: U1.9 (O3), U2.8 (D3), U5.25 (A11)
/Addr12: U1.12 (O4), U2.13 (D4), U5.4 (A12)
/Addr13: U1.15 (O5), U2.14 (D5), U5.28 (A13)
/Addr14: U1.16 (O6), U2.17 (D6), U5.29 (A14)
/Addr15: U1.19 (O7), U2.18 (D7), U5.3 (A15)
/Addr16: U5.2 (A16), U6.19 (PD2)
/DATA0: RN1.3 (R2), U1.3 (D0), U3.2 (O0), U5.13 (Q0), U6.10 (PC0)
/DATA1: RN1.4 (R3), U1.4 (D1), U3.5 (O1), U5.14 (Q1), U6.11 (PC1)
/DATA2: RN1.7 (R6), U1.7 (D2), U3.6 (O2), U5.15 (Q2), U6.12 (PC2)
/DATA3: RN1.8 (R7), U1.8 (D3), U3.9 (O3), U5.17 (Q3), U6.13 (PC3)
/DATA4: RN1.9 (R8), U1.13 (D4), U3.12 (O4), U5.18 (Q4), U6.14 (PC4)
/DATA5: RN1.6 (R5), U1.14 (D5), U3.15 (O5), U5.19 (Q5), U6.15 (PC5)
/DATA6: RN1.5 (R4), U1.17 (D6), U3.16 (O6), U5.20 (Q6), U6.16 (PC6)
/DATA7: RN1.2 (R1), U1.18 (D7), U3.19 (O7), U5.21 (Q7), U6.17 (PC7)
Addr_LSB_LD: U2.11 (LE), U6.5 (PA1)
Addr_MSB_LD: U1.11 (LE), U6.4 (PD7/NRST)
DATA_LD: U3.11 (LE), U6.8 (PD0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, H1.1, H2.1, H3.1, H4.1, J1.4 (GND), J1.5 (Shield), J2.5, J3.1, R1.2, R2.2, U1.1 (OE), U1.10 (GND), U2.1 (OE), U2.10 (GND), U3.10 (GND), U4.3 (GND), U5.16 (GND), U5.22 (~CE), U6.7 (VSS)
unnamed: C1.1, U4.10 (V3)
unnamed: D1.1 (K), R1.1
unnamed: D1.2 (A), U4.6 (TNOW)
unnamed: D2.1 (K), R2.1
unnamed: J1.2 (D-), U4.2 (UD-)
unnamed: J1.3 (D+), U4.1 (UD+)
RX: J3.4, U4.8 (TXD), U6.3 (PD6/URX)
SWDIO: J2.3, U6.18 (PD1/SWIO)
TX: J3.5, U4.9 (RXD), U6.2 (PD5/UTX)
VDD: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, D2.2 (A), J1.1 (VBUS), J2.9, J3.3, RN1.1 (common), U1.20 (VCC), U2.20 (VCC), U3.20 (VCC), U4.7 (VCC), U5.32 (VDD), U6.9 (VDD)
~DATA_OE: U3.1 (OE), U6.6 (PA2)
~ROM_OE: U5.24 (~OE), U6.1 (PD4)
~WR: U5.31 (~WE), U6.20 (PD3)

Notes on the sheet:
デバッガ制御部
RTS ←RX TX→ VCC CTS GND
RX TX GND 3V3 5V
SWCLK SWDIO GND 3V3 5V
WCH-Link E

Board: 2 copper layers, 90.8 x 54.6 mm, 26 parts (2 on the bottom side), 42 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C3, C4, C5, C6, C7, C8",0805,7,0.1u,
C2,CP_Radial_D5.0mm_P2.50mm,1,C_Polarized,
"D1, D2",LED_D3.0mm,2,LED,
"H1, H2, H3, H4",MountingHole_3.2mm_M3_Pad,4,MountingHole_Pad,
J1,USB_B_OST_USB-B1HSxx_Horizontal,1,USB_B,
J2,PinHeader_2x05_P2.54mm_Vertical,1,Conn_02x05_Odd_Even,
J3,PinHeader_1x06_P2.54mm_Horizontal,1,Conn_01x06_Male,
"R1, R2",0603,2,470,
RN1,R_Array_SIP9,1,R_Network08,
"U1, U2, U3",DIP-20_W7.62mm,3,74LS373,
U4,MSOP-10_3x3mm_P0.5mm,1,CH340E,
U5,DIP-32_W15.24mm,1,SST39SF010A,
U6,SSOP-20_4.4x6.5mm_P0.65mm,1,CH32V003F4P6,

## Commit log

2025-02-08 ROMライタハードウェア完成
2025-02-16 ROMの読み書き削除のインターフェイス
2025-02-16 Flash Baker Firmv1.0
2025-02-16 クライアントアプリFlash Bakeryの雛型
